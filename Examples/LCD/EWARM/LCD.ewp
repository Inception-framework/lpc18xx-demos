# IAR project LCD.ewp, settings and files
configuration Internal SRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa092, Pe161
  ICCARM.CCIncludePath2: ..; ..\..\..\Core\CMSIS\Include; ..\..\..\Core\Device\NXP\lpc18xx\Include; ..\..\..\Drivers\include; ..\..\..\Boards
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LCD.srec
  ILINK.IlinkOutputFile: LCD.out
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_1850_db1_iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration External Flash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_1850_db1_extflash_lcd.icf
  ILINK.IlinkExtraOptions: --image_input ..\title_rgb565.bin,TITLE_IMAGE,.image0,4; --image_input ..\diolan_rgb565.bin,DIOLAN_IMAGE,.image1,4; --image_input ..\arrow_rgb565.bin,ARROW_IMAGE,.image2,4; --keep TITLE_IMAGE; --keep DIOLAN_IMAGE; --keep ARROW_IMAGE
  group (top)
    ../: ltv350qv.c main.c tsc2007.c
  group CMSIS-CM3
    ../../../Core/Device/NXP/LPC18xx/Source/Templates/: system_LPC18xx.c
  group Drivers
    ../../../Drivers/source/: lpc18xx_cgu.c lpc18xx_emc.c lpc18xx_gpio.c lpc18xx_i2c.c lpc18xx_lcd.c lpc18xx_scu.c lpc18xx_ssp.c
  group Startup
    ../../../Core/Device/NXP/LPC18xx/Source/Templates/IAR/: startup_LPC18xx.s
