# Keil uVision project CombinedDemo.uvproj, settings and files
target Internal SRAM (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CM3
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf -c --output="$L@L.my.list" "$L@L.axf"
  c flags: Optim=2
  c include: ..\; ..\..\..\Core\CMSIS\Include; ..\..\..\Core\Device\NXP\lpc18xx\Include; ..\..\..\Drivers\include; ..\..\..\Boards
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x18000
  memory RVCT9: RAM 0x10080000 size 0xa000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group CMSIS-CM3
    ../../../Core/Device/NXP/LPC18xx/Source/Templates/: system_LPC18xx.c
  group Drivers
    ../../../Drivers/source/: lpc18xx_cgu.c lpc18xx_emc.c lpc18xx_gpio.c lpc18xx_rgu.c lpc18xx_scu.c
  group Startup
    ../../../Core/Device/NXP/LPC18xx/Source/Templates/ARM/: startup_LPC18xx.s
  group Easyweb
    ../easyweb/: emac.c tcpip.c
  group Source
    ../: hid_usbdesc.c main.c usbd_hid.c
target External Flash (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: CM3
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf -c --output="$L@L.my.list" "$L@L.axf"
  c flags: Optim=2
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x1c000000 size 0x200000
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
