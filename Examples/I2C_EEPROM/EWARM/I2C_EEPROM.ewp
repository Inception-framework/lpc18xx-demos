# IAR project I2C_EEPROM.ewp, settings and files
configuration Internal SRAM (ARM, debug)
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pe161
  ICCARM.CCIncludePath2: ..; ..\..\..\Core\CMSIS\Include; ..\..\..\Core\Device\NXP\lpc18xx\Include; ..\..\..\Drivers\include; ..\..\..\Boards
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_EEPROM.srec
  ILINK.IlinkOutputFile: I2C_EEPROM.out
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_1850_db1_iram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration External Flash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\Linker\EWARM\lpc_1850_db1_extflash.icf
  group (top)
    ../: at24xx.c at24xx.h main.c
  group CMSIS-CM3
    ../../../Core/Device/NXP/LPC18xx/Source/Templates/: system_LPC18xx.c
  group Drivers
    ../../../Drivers/source/: lpc18xx_cgu.c lpc18xx_i2c.c lpc18xx_scu.c
  group Startup
    ../../../Core/Device/NXP/LPC18xx/Source/Templates/IAR/: startup_LPC18xx.s
